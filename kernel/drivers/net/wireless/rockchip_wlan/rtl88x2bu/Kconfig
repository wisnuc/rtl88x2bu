## kernel/drivers/net/wireless/rockchip_wlan/rtl88x2bu/Kconfig
```kconfig
config RTL88x2BU
	tristate "Realtek 8822B/8812B USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8822BU
```
